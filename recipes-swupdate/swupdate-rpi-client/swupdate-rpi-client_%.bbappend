do_install_append() {
    rm -f ${D}${bindir}/notify-swupdate-start
}
